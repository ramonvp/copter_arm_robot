Commit message: Restore orientation for 0 degrees

File: urdf/copter_arm.urdf (robot description, URDF)
Before this commit: robot copter_arm, 3 links, 2 joints
Joints:
- joint free_joint: origin xyz=0 0 1.0 rpy=0 0 0 -> xyz=0 0 1.0 rpy=1.5708 0 0
